Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 91e923dd-ffed-4cf0-a917-f4f4b936a9e5, NumberOfSaves: 12], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Emplazamiento por defecto]
File name: 0001
Time: 2023-11-15T11:12:25-04:00
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (ENU) - IFC 24.1.11.26

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 m
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey: Level:Nivel 1 (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Nivel 1; Type: Nivel 1; Type Id: 927
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Trazo punto; Line Weight: 1; Symbol: Extremo de nivel; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Nivel 1
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (m) = Constraints, Elevation (m)
Nivel 1 | Nivel 1 | 0
Nivel 2 | Nivel 2 | 3

# IfcWindow: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding:Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding, Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding:Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding:417528
In: Nivel 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Deceuninck - 1.White/PVC, Glass
Type - Other - Category: Windows; Altura de antepecho por defecto: 0.8 m; Family Name: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding
Type - Model Properties - Acoustic insulation - Bella Sliding: Rw=29 (-1;-2) dB according to ISO 140-3, ISO 717 **; Acoustic insulation - Everest Max: Rw=33 (-1;-4) dB according to ISO 140-3, ISO 717 **; Air permeability - Bella Sliding: Class 3 according to EN 12207; Air permeability - Everest Max: Class 4 according to EN 12207; Water tightness - Bella Sliding: Class 6A according to EN 12208; Water tightness - Everest Max: Class 9A according to EN 12208; Wind load resistance - Bella Sliding: Class C3/B4 according to EN 12210; Wind load resistance - Everest Max: Class C1/B2 according to EN 12210
Type - Construction - Wall Closure: By host
Type - Dimensions - Doble rail window Height: 1.3 m; Fixed window height: 0.7 m; Glass Height: 2.006 m; Glass Width: 1.706 m; Height: 2.1 m; Max. Height: 2.5 m; Max. Width: 2.5 m; Offset: 0.068 m; Rough Height: 2.032 m; Sash Fit: 0.035 m; Width: 1.8 m
Type - Identity Data - Apertura: Sliding; Glazing capacity: 4 - 20mm; Manufacturer: Deceuninck; Model: Sliding; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; Profundidad constructiva: 60mm; System Composition: Bella Sliding, Everest Max; Technical Area: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 77; Type Name: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding; URL: www.deceuninck.cl
Type - Materials and Finishes - Available colours: https://kuula.co/share/collection/7qGbH?logo=1&info=1&fs=1&vr=0&sd=1&thumbs=1; Frame: Deceuninck - 1.White/PVC; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Structural - Includes reinforcement: yes
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_WindowCommon - IsExternal: no
OverallHeight: 2.10013 m; OverallWidth: 1.80027 m
Pset_QuantityTakeOff - Reference: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding
Pset_WindowCommon - Reference: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding; IsExternal: yes
Other - Family: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding; Family and Type: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding; Head Height: 2.9 m; Host Id: 162781; ON_OFF - Sliding Height: no; ON_OFF - Width: no; Type: Deceuninck_Ventana_doble-riel_fijo-superior_Bella-Sliding; Type Id: 417507
Constraints - Level: Nivel 1; Sill Height: 0.8 m
Dimensions - Area: 8.90859 m2; Volume: 0.0638963 m3
Identity Data - Mark: 62
Phasing - Phase Created: Nueva construcción
